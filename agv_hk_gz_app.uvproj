# Keil uVision project agv_hk_gz_app.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: agv_hk_gz_app
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER, __LOG=1, __LOG_INFO_APP=0,__LOG_DEBUG=0
  c include: .\app;.\drivers;.\drivers\pmbus;.\FreeRTOS\inc;.\FreeRTOS\port\RVDS\ARM_CM3;.\libraries\CMSIS;.\libraries\CMSIS\startup;.\libraries\STM32F10x_StdPeriph_Driver\inc;..\gz_app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ./libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group cmsis
    ./libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group std_periph
    ./libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c
  group kernel
    ./FreeRTOS/src/: event_groups.c list.c queue.c tasks.c
    ./FreeRTOS/port/RVDS/ARM_CM3/: port.c
    ./FreeRTOS/port/MemMang/: heap_2.c
  group driver
    ./drivers/: gpio.c board.c uart.c key.c
  group app
    ./app/: stm32f10x_it.c applications.c tsk_led.c tsk_key.c
